# Repository KeioRoboticsAssociation/ilias2026_mainBoard

## KiCad design NHK2026_mainboard.kicad_pcb

Parts:
C1, C2, C3: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
D1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1: ABS_Encoder; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J2: SPI; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J3: I2C; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J4: SOLENOID_1; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J5: ADC; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J6: PicoScan; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
R1, R3: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
SW1, SW2: SW_Push; SW_PUSH_6mm
U1: TXRX_pokayoke
U2: BNO055
U3: NUCLEO-H753ZI; MODULE_NUCLEO-H753ZI; PARTREV Rev. 2

Connections:
+3V3: C1.1, R1.1, R3.2, U2.1 (VIN), U3.CN11_16 (3V3); also elsewhere on the board
+5V: C2.1, J1.1, U3.CN11_6 (5V_EXT); also elsewhere on the board
+12V: C3.1, J6.1; also elsewhere on the board
ADC_negative: J5.1, U3.CN12_59 (PF12)
ADC_positive: J5.2, U3.CN12_62 (PF11)
BNO_RX: U1.3 (RX1), U3.CN11_63 (PG9)
BNO_TX: U1.1 (TX1), U3.CN12_61 (PG14)
DIR1: U3.CN12_58 (PF3); also elsewhere on the board
DIR2: U3.CN12_38 (PF4); also elsewhere on the board
DIR3: U3.CN12_36 (PF5); also elsewhere on the board
DIR4: U3.CN12_42 (PF10); also elsewhere on the board
ENC_1A: U3.CN12_52 (PE9); also elsewhere on the board
ENC_1B: U3.CN12_56 (PE11); also elsewhere on the board
ENC_2A: U3.CN11_28 (PA0); also elsewhere on the board
ENC_2B: U3.CN12_31 (PB3); also elsewhere on the board
ENC_3A: U3.CN12_43 (PD12); also elsewhere on the board
ENC_3B: U3.CN12_41 (PD13); also elsewhere on the board
ENC_4A: U3.CN12_4 (PC6); also elsewhere on the board
ENC_4B: U3.CN12_19 (PC7); also elsewhere on the board
ENC_CS: J1.5, U3.CN11_57 (PD0)
ENC_LPTIM_1A: U3.CN11_65 (PG12); also elsewhere on the board
ENC_LPTIM_1B: U3.CN11_61 (PE1); also elsewhere on the board
ENC_LPTIM_2A: U3.CN12_25 (PB10); also elsewhere on the board
ENC_LPTIM_2B: U3.CN12_45 (PD11); also elsewhere on the board
FDCAN_1RX: U3.CN12_14 (PA11); also elsewhere on the board
FDCAN_1TX: U3.CN12_12 (PA12); also elsewhere on the board
FDCAN_2RX: U3.CN12_16 (PB12); also elsewhere on the board
FDCAN_2TX: U3.CN12_17 (PB6); also elsewhere on the board
GND: C1.2, C2.2, C3.2, D1.1 (K), J1.4, J2.1, J3.1, J4.1, J6.2, SW1.2, SW2.2, U2.2 (GND), U2.6 (GND), U3.CN11_8 (GND_CN11), U3.CN11_19 (GND_CN11), U3.CN11_20 (GND_CN11), U3.CN11_22 (GND_CN11), U3.CN11_49 (GND_CN11), U3.CN11_60 (GND_CN11), U3.CN11_71 (GND_CN11), U3.CN11_72 (GND_CN11), U3.CN12_9 (GND_CN12), U3.CN12_20 (GND_CN12), U3.CN12_32 (AGND_CN12), U3.CN12_39 (GND_CN12), U3.CN12_54 (GND_CN12), U3.CN12_63 (GND_CN12), U3.CN12_71 (GND_CN12), U3.CN12_72 (GND_CN12); also elsewhere on the board
I2C_SCL: J3.3, U3.CN11_51 (PF1)
I2C_SDA: J3.2, U3.CN11_53 (PF0)
LIMIT1: U3.CN11_59 (PG0); also elsewhere on the board
LIMIT2: U3.CN11_58 (PG1); also elsewhere on the board
LIMIT3: U3.CN11_42 (PG2); also elsewhere on the board
LIMIT4: U3.CN11_44 (PG3); also elsewhere on the board
LIMIT5: U3.CN12_69 (PG4); also elsewhere on the board
LIMIT6: U3.CN12_68 (PG5); also elsewhere on the board
LIMIT7: U3.CN12_70 (PG6); also elsewhere on the board
LIMIT8: U3.CN12_67 (PG7); also elsewhere on the board
LIMIT9: U3.CN12_66 (PG8); also elsewhere on the board
LIMIT10: U3.CN11_56 (PF9); also elsewhere on the board
LIMIT11: U3.CN11_66 (PG10); also elsewhere on the board
LIMIT12: U3.CN11_2 (PC11); also elsewhere on the board
LIMIT13: U3.CN12_49 (PE12); also elsewhere on the board
LIMIT14: U3.CN12_55 (PE13); also elsewhere on the board
LIMIT15: U3.CN12_51 (PE14); also elsewhere on the board
LIMIT16: U3.CN12_53 (PE15); also elsewhere on the board
unnamed: D1.2 (A), R2.1
unnamed: U1.2 (RX2), U2.4 (SCL)
unnamed: U1.4 (TX2), U2.3 (SDA)
unnamed: R1.2, SW1.1, U3.CN11_14 (NRST)
PWM1: U3.CN12_13 (PA6); also elsewhere on the board
PWM2: U3.CN12_29 (PB5); also elsewhere on the board
PWM3: U3.CN12_2 (PC8); also elsewhere on the board
PWM4: U3.CN12_24 (PB1); also elsewhere on the board
PWM5: U3.CN11_50 (PE5); also elsewhere on the board
PWM6: U3.CN11_62 (PE6); also elsewhere on the board
PWM7: U3.CN12_28 (PB14); also elsewhere on the board
PWM8: U3.CN12_26 (PB15); also elsewhere on the board
RS485_1RX: U3.CN12_33 (PA10); also elsewhere on the board
RS485_1TX: U3.CN12_21 (PA9); also elsewhere on the board
RS485_2RX: U3.CN11_43 (PD6); also elsewhere on the board
RS485_2TX: U3.CN11_41 (PD5); also elsewhere on the board
SOLENOID1: J4.2, U3.CN11_32 (PA4)
SOLENOID2: J4.3, U3.CN11_13 (PA13)
SOLENOID3: J4.4, U3.CN11_15 (PA14)
SOLENOID4: J4.5, U3.CN11_17 (PA15)
SPI_1MISO: J2.3, U3.CN12_27 (PB4)
SPI_1MOSI: J2.2, U3.CN11_45 (PD7)
SPI_1SCK: J2.4, U3.CN12_11 (PA5)
SPI_2MISO: J1.2, U3.CN11_35 (PC2)
SPI_2SCK: J1.3, U3.CN11_40 (PD3)
USER_BUTTON: R3.1, SW2.1, U3.CN11_9 (PF6)
USER_LED: R2.2, U3.CN11_1 (PC10)
WTT12L_1Q1: U3.CN11_3 (PC12); also elsewhere on the board
WTT12L_1Q2: U3.CN12_57 (PF13); also elsewhere on the board
WTT12L_2Q1: U3.CN12_50 (PF14); also elsewhere on the board
WTT12L_2Q2: U3.CN12_60 (PF15); also elsewhere on the board
WTT12L_3Q1: U3.CN12_47 (PE10); also elsewhere on the board
WTT12L_3Q2: U3.CN12_18 (PB11); also elsewhere on the board

Notes on the sheet:
ETH_RXD1
ETH_MDC
水晶念の為
PicoScanの電源 git commit -m "hoge"
LD2
SPI
ETH_TXD1
使用可能
I2C
UART_RX
ソレノイド
水晶（from ST-Link）
UART_TX
CAN
ETH_RXD0
BNO055
RS-485
LD1
LOGIC
ETH_REF_CLK
ETH_MDIO
MOTOR
ETH_TX_EN
I/O
BUTTON
エンコーダ インクリメンタル
ETH_CRS_DV
WTT12L
ADC
エンコーダ アブソリュート
リミットスイッチ
水晶発振子
PicoScan

Parts:
C33, C34, C35, C36: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J21: DCMD1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J22: SERVO1; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J23: DCMD2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J24: SERVO2; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J25: DCMD3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J26: SERVO3; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J27: DCMD4; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical
J28: SERVO4; JST_XH_B3B-XH-A_1x03_P2.50mm_Vertical

Connections:
+5VP: C33.1, C34.1, C35.1, C36.1, J22.2, J24.2, J26.2, J28.2; also elsewhere on the board
DIR1: J21.3; also elsewhere on the board
DIR2: J23.3; also elsewhere on the board
DIR3: J25.3; also elsewhere on the board
DIR4: J27.3; also elsewhere on the board
GND: C33.2, C34.2, C35.2, C36.2, J21.1, J22.1, J23.1, J24.1, J25.1, J26.1, J27.1, J28.1; also elsewhere on the board
PWM1: J21.2; also elsewhere on the board
PWM2: J23.2; also elsewhere on the board
PWM3: J25.2; also elsewhere on the board
PWM4: J27.2; also elsewhere on the board
PWM5: J22.3; also elsewhere on the board
PWM6: J24.3; also elsewhere on the board
PWM7: J26.3; also elsewhere on the board
PWM8: J28.3; also elsewhere on the board

Notes on the sheet:
DCMD
SERVO

Parts:
C29, C31, C32: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C30: 25V 470u; CP_Radial_D8.0mm_P3.50mm
J18: WTT12L_1; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J19: WTT12L_2; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
J20: WTT12L_3; JST_XH_B4B-XH-A_1x04_P2.50mm_Vertical
R41, R43, R45, R47, R49, R51: 6.8k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R42, R44, R46, R48, R50, R52: 3.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder

Connections:
+12V: C29.1, C30.1, C31.1, C32.1, J18.1, J19.1, J20.1; also elsewhere on the board
GND: C29.2, C30.2, C31.2, C32.2, J18.3, J19.3, J20.3, R42.2, R44.2, R46.2, R48.2, R50.2, R52.2; also elsewhere on the board
unnamed: J18.2, R41.1
unnamed: J18.4, R43.1
unnamed: J19.2, R45.1
unnamed: J19.4, R47.1
unnamed: J20.2, R49.1
unnamed: J20.4, R51.1
WTT12L_1Q1: R43.2, R44.1; also elsewhere on the board
WTT12L_1Q2: R41.2, R42.1; also elsewhere on the board
WTT12L_2Q1: R47.2, R48.1; also elsewhere on the board
WTT12L_2Q2: R45.2, R46.1; also elsewhere on the board
WTT12L_3Q1: R51.2, R52.1; also elsewhere on the board
WTT12L_3Q2: R49.2, R50.1; also elsewhere on the board

Parts:
C21, C22, C23, C24: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J14: RS485_1; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J15: RS485_2; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
R27, R29, R33, R35: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R28, R30, R31, R32, R34, R36, R37, R38: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U8, U9, U10, U11: UTRS485G-S08-R; SOP-8_3.76x4.96mm_P1.27mm

Connections:
+5V: C21.1, C22.1, C23.1, C24.1, R28.2, R31.2, R34.2, R37.2, U8.2 (~RE), U8.3 (DE), U8.8 (VCC), U9.8 (VCC), U10.2 (~RE), U10.3 (DE), U10.8 (VCC), U11.8 (VCC); also elsewhere on the board
GND: C21.2, C22.2, C23.2, C24.2, J14.1, J15.1, R30.1, R32.1, R36.1, R38.1, U8.5 (GND), U9.2 (~RE), U9.3 (DE), U9.5 (GND), U10.5 (GND), U11.2 (~RE), U11.3 (DE), U11.5 (GND); also elsewhere on the board
unnamed: J14.2, R29.1, R30.2, U8.6 (A)
unnamed: J14.3, R28.1, R29.2, U8.7 (B)
unnamed: J14.4, R27.1, R32.2, U9.6 (A)
unnamed: J14.5, R27.2, R31.1, U9.7 (B)
unnamed: J15.2, R35.1, R36.2, U10.6 (A)
unnamed: J15.3, R34.1, R35.2, U10.7 (B)
unnamed: J15.4, R33.1, R38.2, U11.6 (A)
unnamed: J15.5, R33.2, R37.1, U11.7 (B)
RS485_1RX: U9.1 (RO); also elsewhere on the board
RS485_1TX: U8.4 (DI); also elsewhere on the board
RS485_2RX: U11.1 (RO); also elsewhere on the board
RS485_2TX: U10.4 (DI); also elsewhere on the board

Parts:
C15, C16, C17, C18, C19, C20: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J8: RE_1; PocketHeader_1x05_Vertical
J9: RE_2; PocketHeader_1x05_Vertical
J10: RE_3; PocketHeader_1x05_Vertical
J11: RE_4; PocketHeader_1x05_Vertical
J12: RE_LPTIM1; PocketHeader_1x05_Vertical
J13: RE_LPTIM2; PocketHeader_1x05_Vertical

Connections:
+5V: C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, J8.4, J9.4, J10.4, J11.4, J12.4, J13.4; also elsewhere on the board
ENC_1A: J8.3; also elsewhere on the board
ENC_1B: J8.5; also elsewhere on the board
ENC_2A: J9.3; also elsewhere on the board
ENC_2B: J9.5; also elsewhere on the board
ENC_3A: J10.3; also elsewhere on the board
ENC_3B: J10.5; also elsewhere on the board
ENC_4A: J11.3; also elsewhere on the board
ENC_4B: J11.5; also elsewhere on the board
ENC_LPTIM_1A: J12.3; also elsewhere on the board
ENC_LPTIM_1B: J12.5; also elsewhere on the board
ENC_LPTIM_2A: J13.3; also elsewhere on the board
ENC_LPTIM_2B: J13.5; also elsewhere on the board
GND: C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, J8.1, J9.1, J10.1, J11.1, J12.1, J13.1; also elsewhere on the board

Notes on the sheet:
GND

Parts:
C25, C26, C27, C28: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
J16: FDCAN_1; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
J17: FDCAN_2; JST_XH_B2B-XH-A_1x02_P2.50mm_Vertical
R39, R40: 120; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
U12, U13: MCP2562-E-P; DIP-8_W7.62mm

Connections:
+3V3: C25.1, C27.1, U12.5 (Vio), U13.5 (Vio); also elsewhere on the board
+5V: C26.1, C28.1, U12.3 (VDD), U13.3 (VDD); also elsewhere on the board
FDCAN_1RX: U12.4 (RXD); also elsewhere on the board
FDCAN_1TX: U12.1 (TXD); also elsewhere on the board
FDCAN_2RX: U13.4 (RXD); also elsewhere on the board
FDCAN_2TX: U13.1 (TXD); also elsewhere on the board
GND: C25.2, C26.2, C27.2, C28.2, U12.2 (VSS), U12.8 (STBY), U13.2 (VSS), U13.8 (STBY); also elsewhere on the board
unnamed: J16.1, R39.1, U12.7 (CANH)
unnamed: J16.2, R39.2, U12.6 (CANL)
unnamed: J17.1, R40.1, U13.7 (CANH)
unnamed: J17.2, R40.2, U13.6 (CANL)

Parts:
C4: 25V 470u; CP_Radial_D8.0mm_P3.50mm
C5: 25v 100u; CP_Radial_D5.0mm_P2.00mm
C6, C7, C8, C10, C11, C13: 0.1u; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C9: 25v 470u; CP_Radial_D8.0mm_P3.50mm
C12: 25v 1000u; CP_Radial_D12.5mm_P5.00mm
C14: 16v 100u; CP_Radial_D5.0mm_P2.00mm
D2: +12V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D3: +5V; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D4: +3V3; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D5: +5VP; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D6, D7, D11: RB168MM100TR; D_SOD-123_HandSolder
D8, D9, D10, D12: 1N4148W; D_SOD-123_HandSolder
F1: MF-RX040; C_Disc_D10.0mm_W2.5mm_P5.00mm
F2: RXE110; C_Disc_D10.0mm_W2.5mm_P5.00mm
JP1: Jumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
R4: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R7: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8: 20k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R9: 1.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10: 1.2k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
RV1: 20kB; Valuable_Resistor_TSR-3296W
U4: XT30; AMASS_XT30PW-M_1x02_P2.50mm_Horizontal
U5: BP5293-50; BP5293-xx_horizontal
U6: OKL-T/6-W12N-C; DCDC_OKL-T-xx
U7: BA033CC0FP; TO-252-2

Connections:
+3V3: C13.1, C14.1, D10.2 (A), D12.1 (K), R6.1, U7.3 (OUT); also elsewhere on the board
+5V: C8.1, C9.1, C10.1, D8.2 (A), D9.1 (K), D10.1 (K), R5.1, U5.3 (OUT), U7.1 (IN); also elsewhere on the board
+5VP: C11.1, C12.1, D11.1 (K), R7.1, R10.1, U6.4 (Vout), U6.5 (Sense); also elsewhere on the board
+12V: F1.1, F2.1, R4.1, U4.2; also elsewhere on the board
GND: C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.2 (A), D9.2 (A), D11.2 (A), D12.2 (A), JP1.1 (A), R9.2, R10.2, U4.1, U5.2 (GND), U6.3 (GND), U6.7 (GND), U7.2 (GND); also elsewhere on the board
unnamed: D2.2 (A), R4.2
unnamed: D3.2 (A), R5.2
unnamed: D4.2 (A), R6.2
unnamed: D5.2 (A), R7.2
unnamed: C4.1, C7.1, D6.1 (K), F2.2, R8.1, U6.2 (Vin)
unnamed: D7.2 (A), F1.2
unnamed: C5.1, C6.1, D7.1 (K), D8.1 (K), U5.1 (IN)
unnamed: JP1.2 (B), R8.2, U6.1 (ON/OFF)
unnamed: R9.1, RV1.3
unnamed: RV1.1, RV1.2, U6.6 (Trim)

Notes on the sheet:
RB168MM100TR平均順電流1A?
1N4148平均順電流200mA
